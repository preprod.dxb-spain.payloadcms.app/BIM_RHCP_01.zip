Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-03-04T16:57:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220224_1700(x64) - Exporter 19.2.60.3 - IU alternativa 19.2.60.3
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 04 16:57:43 2022 * Host: LAPTOP-RJEQOEHS * Database: C:\Users\gerod\AppData\Local\Temp\{B5465A2D-F8E5-4ADE-AD9B-B0FAD59EF6B2}\ifc * Database version: 5507 * Database creation date: Fri Mar 04 16:57:43 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 04 16:57:43 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 04 16:57:43 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 24, 0, 5493; RefLongitude: -3, -40, -59, -880065; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 mm

# IfcRoof (8)
In: Nivel 1
Pset_RoofCommon - Reference: Pieza; IsExternal: no; TotalArea: 16 m2
Name (Pieza:...) | Material
139311 | AT_HormigonPorosoyXPS_Baldosa_InverlosaGris3560
139312 | AT_PoliestirenoExtruidoXPS_Panel_ChovaFoam300M80
139313 | IM_Poliester_Geotextil_Geofim200
139314 | IM_LaminaAsfaltica_Lamina_PolitaberCombi40 (LBM 40-FP)
139315 | IM_LaminaAsfaltica_Lamina_PolitaberVel30 (LBM 30-FV)
139316 | IM_ImprimaciónBituminosa_PrimerSR
141502 | Pavimento existente
142222 | Soporte resistente
